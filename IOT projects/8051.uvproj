# Keil uVision project 8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: motor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Led_blink.c 7 segment display(cc).c 7 segment display.c motor.c pooja print.c switch.c Switch_led_optm.c
